# Keil uVision project template_1.uvprojx, settings and files
target template_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: template_1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe --text -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Middlewares\Third_Party\RTT\Inc;..\Core\Inc;..\Middlewares\Third_Party\easylogger\inc;..\Middlewares\Third_Party\CmBacktrace\cm_backtrace;..\Middlewares\Third_Party\Unity;..\Drivers\hal_driver\inc;..\Drivers\handler\inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c rtc.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c self.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/hal_driver
    ../Drivers/hal_driver/src/: ec_bsp_aht21_driver.c
  group Drivers/handler
    ../Drivers/handler/src/: ec_bsp_temperature_handler.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/RTT
    ../Middlewares/Third_Party/RTT/Src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/easylogger
    ../Middlewares/Third_Party/easylogger/src/: elog.c elog_utils.c
    ../Middlewares/Third_Party/easylogger/port/: elog_port.c
  group Middlewares/CmBacktrace
    ../Middlewares/Third_Party/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../Middlewares/Third_Party/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Middlewares/Unity
    ../Middlewares/Third_Party/Unity/: unity.c
software components: CMSIS:CORE 4.3.0
